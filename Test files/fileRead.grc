options:
  parameters:
    author: prabathbk
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    comment: baud
    value: '45.4545'
  states: {}
- name: center
  id: variable
  parameters:
    value: 2.21e3
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: '170'
  states: {}
- name: mark
  id: variable
  parameters:
    value: 2.295e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: space
  id: variable
  parameters:
    value: 2.125e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3000'
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    append: 'True'
    bits_per_sample1: FORMAT_PCM_16
    file: /media/prabathbk/EDUCATION/Acedemics/Sem 3/Com design project/Project/Test files/testFIle.py
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /media/prabathbk/EACCC591CCC55889/Users/praba/Downloads/Music/Salli - Sarith and Surith - Tune.lk.wav
    repeat: 'False'
  states: {}

connections:
- [band_pass_filter_0, '0', audio_sink_0, '0']
- [band_pass_filter_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
